# Keil uVision project A5133.uvproj, settings and files
target Target 1 (MCS-51)
  device: A8107 AMICCOM
  cpu: IRAM(0 - 0xFF) CLOCK(16000000)
  output: A5133 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: M:\SA\SA_FW\jph\code_51\A7102\source\
  group Source Group 1
    ../source/: Main.c Uti.c
